EXTRA_OECONF_remove = "--disable-static "
