CFLAGS += " -Wno-error=unused-result -Wno-error=stringop-truncation"
DEPENDS += " webconfig-framework "
